DESCRIPTION = ""
LICENSE = "BSD-3-Clause"
LIC_FILES_CHKSUM = "file://LICENSE;md5=f5138d63fd9e7ecca79f04796e43bda4"

inherit hackage

DEPENDS:append = "hkg-integer-logarithms hkg-primitive"

SRC_URI[md5sum] = ""
SRC_URI[sha256sum] = ""

PR = "r1"
