DESCRIPTION = "Regex library for GHC"
LICENSE = "BSD-3-Clause"
LIC_FILES_CHKSUM="file://LICENSE;md5=5a9760d05990120048023e30741b4d71"
DEPENDS += "hkg-mtl hkg-regex-posix"

inherit hackage

SRC_URI[md5sum] = "d6becec95ea8098cab663116fdce60a5"
SRC_URI[sha256sum] = "ee0374f780378e8c04a63d9cbaca525e116dbe2bdce4cff3abaffc28d4e99afe"
