DESCRIPTION = "Some useful control operators for looping."
LICENSE = "GPL-2.0-only"
LIC_FILES_CHKSUM="file://${COMMON_LICENSE_DIR}/GPL-2.0-only;md5=801f80980d171dd6425610833a22dbe6"

inherit hackage

SRC_URI[md5sum] = "f308cb97953e65637bf75d0c39a67266"
SRC_URI[sha256sum] = "610f2888ca11362e012e1ff9ff7269862fad505bc24ba80ff1fa66b9a6e5681b"

PR = "r1"
